# Keil uVision project SWM330_StdPeriph_Driver.uvprojx, settings and files
target SWM330 (6160000::V6.16::ARMCLANG)
  device: SWM330xG Synwit
  pack: Synwit.SWM32_New.0.2.9
  cpu: CPUTYPE("Cortex-M33") DSP CLOCK(12000000) ESEL ELITTLE
  output: SWM330_QSPI0_NAND +hex
  AfterMake: cmd.exe /C copy "out\%L" "out\@L.FLM"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM330_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\APP\linker.sct
  link misc: --diag_suppress L6305
  group APP
    ./APP/: FlashDev.c FlashPrg.c W25N01G.c
  group CSL\StdPD
    ./CSL/SWM330_StdPeriph_Driver/: SWM330_port.c SWM330_gpio.c SWM330_qspi.c SWM330_flash.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM330.c
